options:
  parameters:
    category: Custom
    description: IEEE 802.15.4 Transceiver using CSS PHY
    generate_options: qt_gui
    id: transceiver_CSS_loopback
    output_language: python
    realtime_scheduling: '1'
    title: IEEE 802.15.4 Transceiver using CSS PHY
  states: {}

blocks:
- name: ampl
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1.0'
    value: '0.02'
  states: {}
- name: c
  id: variable
  parameters:
    value: ieee802_15_4.css_phy(chirp_number=4, phy_packetsize_bytes=len(text_msg)+15)
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '10'
    stop: '100000'
    value: '500'
  states: {}
- name: enable
  id: variable_qtgui_chooser
  parameters:
    label0: '"off"'
    label1: '"on"'
    num_opts: '2'
    option0: '0.0'
    option1: '1.0'
    type: real
    value: '1.0'
  states: {}
- name: freq_off
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-5e6'
    step: 1e5
    stop: 5e6
    value: '0'
  states: {}
- name: interval
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '10'
    step: '1'
    stop: '1000'
    value: '300'
  states: {}
- name: pad_len
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '0'
  states: {}
- name: phi
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-np.pi'
    step: '0.01'
    stop: np.pi
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e6
  states: {}
- name: text_msg
  id: variable
  parameters:
    value: '"This is a test message"'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: np.exp(1j*phi)*enable
    type: complex
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: ampl
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_off
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/sensor.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern(text_msg)
    period: interval
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_vector_insert_x_0
  id: blocks_vector_insert_x
  parameters:
    offset: 3*c.nsamp_frame
    period: 3*c.nsamp_frame
    type: complex
    vector: '[0 for i in range(pad_len)]'
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {state: disabled}
- name: ieee802_15_4_css_phy_1
  id: ieee802_15_4_css_phy
  parameters:
    bits_per_cw: c.bits_per_symbol
    chirp_seq: c.chirp_seq
    codewords: c.codewords
    intlv_seq: c.intlv_seq
    len_sub: '38'
    nbytes_payload: c.phy_packetsize_bytes
    nsamp_frame: c.nsamp_frame
    num_subchirps: c.n_subchirps
    nzeros_padding: c.padded_zeros
    phr: c.PHR
    preamble: c.preamble
    sfd: c.SFD
    sym_per_frame: c.nsym_frame
    threshold: '0.95'
    time_gap_1: c.time_gap_1
    time_gap_2: c.time_gap_2
  states: {}
- name: ieee802_15_4_mac_0
  id: ieee802_15_4_mac
  parameters:
    debug: 'True'
    dst: '0xffff'
    dst_pan: '0x1aaa'
    fcf: '0x8841'
    seq_nr: '0'
    src: '0x3344'
  states: {}
- name: ieee802_15_4_rime_stack_0
  id: ieee802_15_4_rime_stack
  parameters:
    bc_channels: '[129]'
    rime_add: '[23,42]'
    ruc_channels: '[132]'
    uc_channels: '[131]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import ieee802_15_4
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'you can connect to the Socket PDU with: ''nc -u localhost 52002'''
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '2405000000'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_delay_0, '0']
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', ieee802_15_4_css_phy_1, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '0']
- [blocks_message_strobe_0, strobe, ieee802_15_4_rime_stack_0, bcin]
- [blocks_multiply_xx_0, '0', blocks_vector_insert_x_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '1']
- [blocks_socket_pdu_0_0, pdus, ieee802_15_4_rime_stack_0, bcin]
- [blocks_vector_insert_x_0, '0', blocks_multiply_xx_1, '1']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_css_phy_1, '0', blocks_multiply_xx_0, '1']
- [ieee802_15_4_css_phy_1, rxout, ieee802_15_4_mac_0, pdu in]
- [ieee802_15_4_mac_0, app out, ieee802_15_4_rime_stack_0, fromMAC]
- [ieee802_15_4_mac_0, pdu out, foo_wireshark_connector_0, in]
- [ieee802_15_4_mac_0, pdu out, ieee802_15_4_css_phy_1, txin]
- [ieee802_15_4_rime_stack_0, bcout, blocks_socket_pdu_0_0, pdus]
- [ieee802_15_4_rime_stack_0, toMAC, ieee802_15_4_mac_0, app in]

metadata:
  file_format: 1
